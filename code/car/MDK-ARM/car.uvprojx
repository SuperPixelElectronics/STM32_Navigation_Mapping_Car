# Keil uVision project car.uvprojx, settings and files
target car (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: car +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/hardware;../Drivers/hardware/action;../Drivers/hardware/NRF24L01;../Drivers/hardware/OLED;../Drivers/hardware/position;../Drivers/hardware/VL53L1/core;../Drivers/hardware/VL53L1/platform;..\Drivers\hardware\interaction
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Drivers/hardware/: system.c system.h buzzer.c buzzer.h led.c led.h uart_app.c uart_app.h car_map.c car_map.h path_planing.c path_planing.h
  group Hardware/OLED
    ../Drivers/hardware/OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h
  group Hardware/NRF24L01
    ../Drivers/hardware/NRF24L01/: NRF24L01.h nRF24L01_API.c nRF24L01_API.h
  group Hardware/action
    ../Drivers/hardware/action/: motor.c motor.h trajectory_tracker.c trajectory_tracker.h
  group Hardware/position
    ../Drivers/hardware/position/: encoder.c encoder.h mpu6050.c mpu6050.h position.c position.h
  group Hardware/VL53L1/core
    ../Drivers/hardware/VL53L1/core/: vl53l1_api.c vl53l1_api.h vl53l1_api_calibration.c vl53l1_api_calibration.h vl53l1_api_core.c vl53l1_api_core.h vl53l1_api_debug.c vl53l1_api_debug.h vl53l1_api_preset_modes.c vl53l1_api_preset_modes.h vl53l1_api_strings.c vl53l1_api_strings.h vl53l1_core.c vl53l1_core.h vl53l1_core_support.c vl53l1_core_support.h vl53l1_def.h vl53l1_error_codes.h vl53l1_error_exceptions.h vl53l1_error_strings.c vl53l1_error_strings.h vl53l1_ll_def.h vl53l1_ll_device.h vl53l1_nvm_map.h vl53l1_preset_setup.h vl53l1_register_funcs.c vl53l1_register_funcs.h vl53l1_register_map.h vl53l1_register_settings.h vl53l1_register_structs.h vl53l1_silicon_core.c vl53l1_silicon_core.h vl53l1_tuning_parm_defaults.h vl53l1_wait.c vl53l1_wait.h
  group Hardware/VL53L1/platform
    ../Drivers/hardware/VL53L1/platform/: IOI2C.c IOI2C.h vl53l1.h vl53l1_platform.c vl53l1_platform.h vl53l1_platform_log.h vl53l1_platform_user_config.h vl53l1_platform_user_data.h vl53l1_platform_user_defines.h vl53l1_types.h vl53l1x.c
  group Hardware/interaction
    ../Drivers/hardware/interaction/: key.c key.h show.c show.h user_interaction.c user_interaction.h
software components: CMSIS:CORE 5.6.0
